## drivers/staging/rfm12b/Kconfig
```kconfig
config RFM12B
	tristate "Drivers for RFM12B modules"
	help
	  Say Y if you want to have support for Hope RF RFM12B modules.
```
